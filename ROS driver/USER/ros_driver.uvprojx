# Keil uVision project ros_driver.uvprojx, settings and files
target ros_driver (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ros_driver +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\MOTOR;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ENCODER;..\HARDWARE\Millisecondtime;..\HARDWARE\DataScope_DP;..\HARDWARE\PID;..\HARDWARE\Battery;..\HARDWARE\Time;..\HARDWARE\Usart3;..\HARDWARE\odeometry
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.cpp
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.cpp
    ../HARDWARE/MOTOR/: motor.cpp
    ../HARDWARE/ENCODER/: encoder.cpp
    ../HARDWARE/Millisecondtime/: millisecondtime.c
    ../HARDWARE/DataScope_DP/: DataScope_DP.C
    ../HARDWARE/PID/: PID.cpp
    ../HARDWARE/Battery/: battery.cpp
    ../HARDWARE/Time/: time.cpp
    ../HARDWARE/Usart3/: usart3.c
    ../HARDWARE/odeometry/: odometry.cpp
